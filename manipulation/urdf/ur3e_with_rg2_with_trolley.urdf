Commit message: incoming conflict

File: manipulation/urdf/ur3e_with_rg2_with_trolley.urdf (robot description, URDF)
Before this commit: robot ur3e_with_rg2, 21 links, 20 joints
Links:
- link trolley: geometry collision box size=0.73 0.71 0.9; visual box size=0.73 0.71 0.9
