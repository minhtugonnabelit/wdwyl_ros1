Commit message: Update lookup mechanism

File: urdf/ur3e_with_rg2_with_trolley.urdf (robot description, URDF)
Before this commit: robot ur3e_with_rg2, 21 links, 20 joints
Links:
- link task_plate: mass None -> 0.1
- link trolley: mass None -> 0.1
